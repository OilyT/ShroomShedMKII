<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ShroomShed_MKII.ewp</path>
  </project>
  <batchBuild />
</workspace>
